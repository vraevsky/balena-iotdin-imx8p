LED_FILE:iotdin-imx8p = "/sys/class/leds/Green_A/brightness"
